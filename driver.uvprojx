# Keil uVision project driver.uvprojx, settings and files
target Real (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: driver
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Include;.\Librairies\LSM9DS1;.\Tests
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: Driver_GPIO.c main.c Driver_Timer.c Driver_ADC.c Service_IMU.c Driver_I2C.c Driver_USART.c Service_Girouette.c Service_Servo.c Service_Communication.c
  group Include
    ./Include/: Driver_GPIO.h Driver_Timer.h Driver_ADC.h Service_Servo.h Service_IMU.h Driver_I2C.h Driver_USART.h Service_Girouette.h Service_Communication.h
  group Tests
    ./Tests/: test_GPIO_Timer.c test_PWM.c test_ADC.c test_IMU.c tests.h test_USART.c test_Servo.c test_Communication.c
target Simulation (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Include;.\Librairies\LSM9DS1;.\Tests
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
